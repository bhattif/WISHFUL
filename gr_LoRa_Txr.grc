<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>bw</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code_rate</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>frequency</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>3.1e9</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldr</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>num_steps</key><value>999</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spreading_factor</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>15</value></param>
<param><key>label</key><value>tx_gain</value></param>
<param><key>max</key><value>89</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>100</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>(2 * math.pi * offset) / samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>lora_encode</key>
<param><key>id</key><value>lora_encode_0</value></param>
<param><key>code_rate</key><value>code_rate</value></param>
<param><key>header</key><value>header</value></param>
<param><key>low_data_rate</key><value>ldr</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
</block>
<block>
<key>lora_mod</key>
<param><key>id</key><value>lora_mod_0</value></param>
<param><key>spreading_factor</key><value>spreading_factor</value></param>
<param><key>sync_word</key><value>0x12</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Setting sample rate to the highest expected bandwidth enables the bandwidth to be changed on the fly via the resampler.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Resample to the desired bandwidth.</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>samp_rate/bw</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>lora_encode_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_encode_0</source_block_id><sink_block_id>lora_mod_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_mod_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
